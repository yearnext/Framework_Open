# IAR project STM32F1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: application; paltform; ..\..\compiler; ..\..\hal; ..\..\kernel; ..\..\hal\arch\arm; ..\..\utility\STM32F1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F1xx.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    application/: application.c fw_conf.h
  group Board
    paltform/: board.c bsp.h bsp_led.c
  group HAL/Library
    ../../utility/STM32F1xx_HAL_Driver/Src/iar/: startup_stm32f103xe.s
    ../../utility/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c system_stm32f1xx.c
  group HAL/MSP
    paltform/: msp_conf.h
    ../../hal/mcu/stm32f1xx/: msp_stm32f1xx.c msp_stm32f1xx.h stm32f1xx_adc.c stm32f1xx_gpio.c stm32f1xx_pwm.c stm32f1xx_spi.c stm32f1xx_timer.c stm32f1xx_uart.c stm32f1xx_wdg.c
  group Kernel
    ../../kernel/: fw_core.c fw_server.c fw_timer.c
