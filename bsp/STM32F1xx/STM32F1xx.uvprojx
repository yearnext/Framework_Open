# Keil uVision project STM32F1xx.uvprojx, settings and files
target Framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Framework +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE, USE_FULL_LL_DRIVER
  c include: .\application;.\paltform;..\..\compiler;..\..\kernel;..\..\utility\STM32F1xx_HAL_Driver\Inc;..\..\hal\arch\arm;..\..\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.fw_init_fn.*)
  group Application
    ./application/: fw_conf.h application.c
  group Board
    ./paltform/: bsp.h board.c bsp_led.c
  group Kernel
    ../../kernel/: fw_timer.c fw_core.c fw_server.c
  group MSP
    ./paltform/: msp_conf.h
    ../../hal/mcu/stm32f1xx/: msp_stm32f1xx.c stm32f1xx_adc.c stm32f1xx_gpio.c stm32f1xx_pwm.c stm32f1xx_spi.c stm32f1xx_timer.c stm32f1xx_uart.c stm32f1xx_wdg.c
  group LL-Library
    ../../utility/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_i2c.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_usart.c stm32f1xx_ll_tim.c stm32f1xx_ll_gpio.c system_stm32f1xx.c
    ../../utility/STM32F1xx_HAL_Driver/Src/arm/: startup_stm32f103xe.s
