# Keil uVision project STM32L4xx.uvprojx, settings and files
target STM32L4xx-Alpha (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Framework-STM32L476 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=4000000,EXTERNALSAI1_CLOCK_VALUE=2097000,EXTERNALSAI2_CLOCK_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L475xx
  c include: .\application;.\paltform;..\..\compiler;..\..\hal;..\..\hal\arch\arm;..\..\kernel;..\..\utility\STM32L4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --keep *.o(.fw_init_fn.*)
  group Application
    ./application/: fw_conf.h application.c
  group BSP
    ./paltform/: bsp.h board.c bsp_led.c
  group Kernel
    ../../kernel/: fw_core.c fw_timer.c fw_server.c
  group MSP
    ./paltform/: msp_conf.h
    ../../hal/mcu/stm32l4xx/: msp_stm32l4xx.h msp_stm32l4xx.c stm32l4xx_gpio.c stm32l4xx_wdg.c stm32l4xx_adc.c
  group HAL
    ../../hal/: hal_device.h
    ../../hal/general/: hal_device.c
  group LL_Library
    ../../utility/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_utils.c stm32l4xx_ll_usart.c stm32l4xx_ll_tim.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_rcc.c stm32l4xx_ll_pwr.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_lptim.c stm32l4xx_ll_gpio.c system_stm32l4xx.c
    ../../utility/STM32L4xx_HAL_Driver/Src/arm/: startup_stm32l475xx.s
software components: CMSIS:CORE 5.2.0
