# IAR project STM32L4xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: application; paltform; ..\..\compiler; ..\..\hal; ..\..\kernel; ..\..\hal\arch\arm; ..\..\utility\STM32L4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F1xx.out
  ILINK.IlinkIcfFile: linker_scripts\stm32l475ve.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    application/: application.c fw_conf.h
  group Board
    paltform/: board.c bsp.h bsp_led.c
  group HAL/Library
    ../../utility/STM32L4xx_HAL_Driver/Src/iar/: startup_stm32l476xx.s
    ../../utility/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_crc.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c system_stm32l4xx.c
  group HAL/MSP
    ../../hal/mcu/stm32l4xx/: msp_stm32l4xx.c msp_stm32l4xx.h stm32l4xx_gpio.c
  group Kernel
    ../../kernel/: fw_core.c fw_server.c fw_timer.c
